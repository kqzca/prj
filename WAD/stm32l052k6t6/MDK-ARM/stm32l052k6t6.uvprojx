# Keil uVision project stm32l052k6t6.uvprojx, settings and files
target stm32l052k6t6 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L052K6 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: stm32l052k6t6 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L052xx
  c misc: --C99
  c include: ../Inc;           C:/Users/qunzhang/STM32Cube/Repository/STM32Cube_FW_L0_V1.5.0/Drivers/STM32L0xx_HAL_Driver/Inc;           C:/Users/qunzhang/STM32Cube/Repository/STM32Cube_FW_L0_V1.5.0/Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;           C:/Users/qunzhang/STM32Cube/Repository/STM32Cube_FW_L0_V1.5.0/Drivers/CMSIS/Include;           C:/Users/qunzhang/STM32Cube/Repository/STM32Cube_FW_L0_V1.5.0/Drivers/CMSIS/Device/ST/STM32L0xx/Include;      C:/Users/qunzhang/STM32Cube/Repository/STM32Cube_FW_L0_V1.5.0/Middlewares/ST/STM32_USB_Device_Library/Core/Inc;      C:/Users/qunzhang/STM32Cube/Repository/STM32Cube_FW_L0_V1.5.0/Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Drivers/STM32L0xx_HAL_Driver
    C:/Users/qunzhang/STM32Cube/Repository/STM32Cube_FW_L0_V1.5.0/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_tim_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal.c stm32l0xx_hal_flash.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_pwr.c stm32l0xx_hal_dac.c stm32l0xx_hal_rtc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_tim.c stm32l0xx_hal_cortex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pcd.c stm32l0xx_hal_rtc_ex.c
  group Application/MDK-ARM
    ./: startup_stm32l052xx.s
  group Application/User
    ../Src/: stm32l0xx_hal_msp.c main.c stm32l0xx_it.c gpio.c usbd_conf.c usbd_dfu_if.c usb_device.c usbd_desc.c rtc.c
  group Drivers/CMSIS
    C:/Users/qunzhang/STM32Cube/Repository/STM32Cube_FW_L0_V1.5.0/Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Middlewares/USB_Device_Library
    C:/Users/qunzhang/STM32Cube/Repository/STM32Cube_FW_L0_V1.5.0/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_core.c usbd_ctlreq.c
    C:/Users/qunzhang/STM32Cube/Repository/STM32Cube_FW_L0_V1.5.0/Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
software components: CMSIS:CORE 4.1.0
