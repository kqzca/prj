# Keil uVision project WAD_USBCOM.uvprojx, settings and files
target WAD_USBCOM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L052K6 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: WAD_USBCOM +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L052xx
  c misc: --C99
  c include: ../Inc;           ../Drivers/STM32L0xx_HAL_Driver/Inc;           ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;           ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;           ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;           ../Drivers/CMSIS/Include;           ../Drivers/CMSIS/Device/ST/STM32L0xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_flash_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_cortex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal.c stm32l0xx_hal_dac.c stm32l0xx_hal_rtc.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_adc.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pwr.c stm32l0xx_hal_adc_ex.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/MDK-ARM
    ./: startup_stm32l052xx.s
  group Application/User
    ../Src/: usbd_cdc_if.c usbd_desc.c rtc.c main.c stm32l0xx_hal_msp.c usbd_conf.c stm32l0xx_it.c usb_device.c dac.c i2c.c gpio.c adc.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
software components: CMSIS:CORE 4.1.0
